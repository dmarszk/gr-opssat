<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>os_demod_decode_satnogs</value></param>
<param><key>author</key><value>Fischer Benjamin, Mladenov Tom, Marszk Dominik</value></param>
<param><key>description</key><value>AX.25 beacons descrambler and decoder application for the ESA OPS-SAT mission</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>OPS-SAT UHF demodulator/decoder</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>csp_frames.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/data/home_user/opssat/sdr/gr-opssat/apps/opssat_frames.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>ax_frame_len</value></param>
<param><key>packet_len</key><value>110</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>ax_frame_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>500</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0xA9</value></param>
<param><key>reset_tag_key</key><value>"packet_len"</value></param>
<param><key>seed</key><value>0xFF</value></param>
</block>
<block>
<key>satellites_check_address</key>
<param><key>id</key><value>satellites_check_address_0</value></param>
<param><key>address</key><value>DP0OPS</value></param>
<param><key>direction</key><value>"from"</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>satellites_strip_ax25_header</key>
<param><key>id</key><value>satellites_strip_ax25_header_0</value></param>
</block>
<block>
<key>satellites_submit</key>
<param><key>id</key><value>satellites_submit_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>url</key><value>https://db.satnogs.org/api/telemetry/</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>hdlc_frame</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>payload</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_2</value></param>
<param><key>stream_id</key><value>tm_fwd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>hdlc_frame</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>payload</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tm_fwd</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:38211</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0_0_0</source_block_id><sink_block_id>satellites_decode_rs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_check_address_0</source_block_id><sink_block_id>satellites_strip_ax25_header_0</sink_block_id><source_key>ok</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_check_address_0</source_block_id><sink_block_id>virtual_sink_0_0_2</sink_block_id><source_key>ok</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_strip_ax25_header_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>satellites_check_address_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>satellites_submit_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
